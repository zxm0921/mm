# Keil uVision project demo.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\RTE\Device\STM32F407ZE;.\RTE;..\uC-CPU\ARM-Cortex-M4\RealView;..\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\uCOS-III\Source;..\uC-CPU;..\uC-LIB;..\BSP;..\APP;..\Listings;..\Objects;..\RTE;..\RTE\Device\STM32F407ZE;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\HARDWARE\BEEP;..\HARDWARE\DHT;..\HARDWARE\IR;..\HARDWARE\IWDG;..\HARDWARE\KEY;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\OLED;..\HARDWARE\RTC;..\FWLIB\STM32F4xx_StdPeriph_Driver\src;..\USER;..\HARDWARE\BLUE_TEETH;..\HARDWARE\FIRE;..\HARDWARE\KEYBOARD;..\HARDWARE\RFID;..\HARDWARE\SMOKE;..\HARDWARE\SR04
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group BSP
    ../BSP/: bsp.c bsp.h
  group UC-CPU
    ../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group UC-LIB
    ../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOS-Ⅲ
    ../uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
    ../uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group CORE
    ../RTE/Device/STM32F407ZE/: startup_stm32f40_41xxx.s
    ../CORE/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/DHT/: dht11.c
    ../HARDWARE/IR/: ir.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: bmp.c oled.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/BLUE_TEETH/: blue_teeth.c
    ../HARDWARE/FIRE/: fire.c
    ../HARDWARE/KEYBOARD/: keyboard.c
    ../HARDWARE/RFID/: MFRC522.c RFID.c
    ../HARDWARE/SMOKE/: smoke.c
    ../HARDWARE/SR04/: sr04.c
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c
